Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: couronne_l37.ifc.ifc
Time: 2016-09-26T08:50:57
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Couronne L37
ePset_BIMobject_Lena - Colour: White RAL 9016; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Couronne L37; SKU (BO_prodsku): L37; ManufacturName (BO_Manufac): Blￃﾥ Station; ProductFamily (BO_prodfam): Tables; ProductGroup (BO_prodgroup): Couronne; ManufacturCountry (BO_mancont): Sweden; DesignCountry (BO_designcont): Sweden; PublishDate (BO_publisdat): 9/6/2016; EditionNumber (BO_edinum): 1; Width (BO_width): 370; Height (BO_height): 550; Depth (BO_depth): 370; Weight (BO_weight): 12.9; QR (BO_boqrurl): http://bimobject.com/blastation/product/L37; ProductDataUrl (BO_prodaturl): bimobject.com/blastation/product/L37; MaterialMain (BO_mainmat): Steel; BimObjectCategory (BO_bocat): Tables; IfcClassification (BO_ifcclas): Furniture; UnspcCode (BO_unspc): 56; Uniclass14Code (BO_uniclass_1_4_code): L8211; Uniclass14Description (BO_uniclass_1_4_desc): Furniture; NBSReference (BO_nbs_ref): 31-12; NBSReferenceDescription (BO_nbs_desc): Chairs, Seats And Bench Seating; MasterFormat2014Code (BO_masterformat2014_code): 12 00 00; MasterFormat2014Description (BO_masterformat2014_name): Furnishings; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
